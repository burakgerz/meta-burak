FILESEXTRAPATHS_prepend :="${THISDIR}/files:"
SRC_URI += "file://defconfig"
KERNEL_DEFCONFIG = "${WORKDIR}/defconfig"
